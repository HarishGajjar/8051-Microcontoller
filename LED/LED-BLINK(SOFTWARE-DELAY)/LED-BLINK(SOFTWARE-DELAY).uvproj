# Keil uVision project LED-BLINK(SOFTWARE-DELAY).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: LED-BLINK(SOFTWARE-DELAY) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 1Second delay(software).c documentation.txt
